/* CONFIDENTIAL */
/*_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_*/
/*_/_/_/        $DWG-No.: sent_mmng.c                                                       _/_/_/_*/
/*_/_/_/        $Content: SENT Manager Implementation                                       _/_/_/_*/
/*_/_/_/        $Category: Source File                                                     _/_/_/_*/
/*_/_/_/        $Date: 2024                                                               _/_/_/_*/
/*_/_/_/        $Design: SENT Driver Team                                                 _/_/_/_*/
/*_/_/_/        $Header$                                                                  _/_/_/_*/
/*_/_/_/        $Copyright(C) Delphi Company                                              _/_/_/_*/
/*_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_/_*/

/*###############################################################################################*/
/*###                                     $INCLUDE FILES$                                    ####*/
/*###############################################################################################*/
#include "t_gentypes.h"  /* For Global Data Types */
#include "sent_fexi.h"   /* For external resource declarations */
#include "sent_sgpf.h"
#include "sent_sect.h"
#include "sent_segr.h"

/*+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++*/
/*+++                                     $FUNCTIONS$                                          +++*/
/*+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++*/

/*************************************************************************************************/
/*************************************************************************************************/
/****       $Function: InitSENT_ResetToKeyOn                                                   ****/
/****       $Content: Initialize SENT components on controller reset to key on                  ****/
/****                                                                                          ****/
/****       $argument: void                                                                    ****/
/****       $return value: void                                                                ****/
/*************************************************************************************************/
/*************************************************************************************************/
FARFUNC void InitSENT_ResetToKeyOn(void)
{
    InitSENT_GPF_ResetToKeyOn();
    InitSENT_ECT_ResetToKeyOn();
    InitSENT_EGR_ResetToKeyOn();
}

/*************************************************************************************************/
/*************************************************************************************************/
/****       $Function: MngSENT_BaseLoopTasks                                                   ****/
/****       $Content: Main SENT handler for base loop tasks                                    ****/
/****                                                                                          ****/
/****       $argument: void                                                                    ****/
/****       $return value: void                                                                ****/
/*************************************************************************************************/
/*************************************************************************************************/
FARFUNC void MngSENT_BaseLoopTasks(void)
{
    ProcessSENT_ECT_MessageData();
    ProcessSENT_GPF_Press_MessageData();
    ProcessSENT_GPF_Temp_MessageData();
}

/*************************************************************************************************/
/*************************************************************************************************/
/****       $Function: MngSENT_125msTasks                                                      ****/
/****       $Content: Process SENT tasks every 125ms when engine not running                   ****/
/****                                                                                          ****/
/****       $argument: void                                                                    ****/
/****       $return value: void                                                                ****/
/*************************************************************************************************/
/*************************************************************************************************/
FARFUNC void MngSENT_125msTasks(void)  
{
    if ((CbFALSE == GetVIOS_EngSt_Crank()) && (CbFALSE == GetVIOS_EngSt_Run()))
    {
        ProcessSENT_GPF_Press_MessageData();
        ProcessSENT_EGR_DeltPres_MessageData();
    }
}

/*************************************************************************************************/
/*************************************************************************************************/
/****       $Function: MngSENT_6X_EventTasks                                                   ****/
/****       $Content: Process SENT tasks on 6X event when engine running                       ****/
/****                                                                                          ****/
/****       $argument: void                                                                    ****/
/****       $return value: void                                                                ****/
/*************************************************************************************************/
/*************************************************************************************************/
FARFUNC void MngSENT_6X_EventTasks(void)  
{
    if ((CbTRUE == GetVIOS_EngSt_Crank()) || (CbTRUE == GetVIOS_EngSt_Run()))
    {
        ProcessSENT_GPF_Press_MessageData();
    }
}

/*************************************************************************************************/
/*************************************************************************************************/
/****       $Function: MngSENT_12X_EventTasks                                                  ****/
/****       $Content: Process SENT tasks on 12X event when engine running                      ****/
/****                                                                                          ****/
/****       $argument: void                                                                    ****/
/****       $return value: void                                                                ****/
/*************************************************************************************************/
/*************************************************************************************************/
FARFUNC void MngSENT_12X_EventTasks(void)
{
    if ((CbTRUE == GetVIOS_EngSt_Crank()) || (CbTRUE == GetVIOS_EngSt_Run()))
    {
        ProcessSENT_EGR_DeltPres_MessageData();
    }
}

/*-----------------------------------------------------------------------------------------------*/
/*-----------------------------------------------------------------------------------------------*/
/*---                                   REVISION MANAGEMENT                                    ---*/
/*-----------------------------------------------------------------------------------------------*/
/*-----------------------------------------------------------------------------------------------*/

/*-----------------------------------------------------------------------------------------------*/
/*---                                                                                         ---*/
/*---    $Rev:No:    date:       name:       company:    minute:    content:                 ---*/
/*---    $Rev:0      2024-01-14                                    Initial version           ---*/
/*---                                                                                         ---*/
/*-----------------------------------------------------------------------------------------------*/
/*---
        $Log$
                                                                                              ---*/
/*-----------------------------------------------------------------------------------------------*/